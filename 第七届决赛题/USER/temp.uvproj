# Keil uVision project temp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: temp +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\LIBRARY\STM32F10x_StdPeriph_Driver\inc;..\HARDWARE\LCD;..\HARDWARE\ADC;..\USER;..\HARDWARE\PWM;..\HARDWARE\INPUT;..\HARDWARE\RTC;..\HARDWARE\EEPROM;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\UART
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../LIBRARY/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../LIBRARY/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../LIBRARY/CMSIS/CM3/CoreSupport/: core_cm3.c
  group USER
    ./: main.c stm32f10x_it.c
  group LIBRARY
    ../LIBRARY/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/INPUT/: input.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/EEPROM/: eeprom.c i2c.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart.c
